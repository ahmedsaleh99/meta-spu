SUMMARY = "Python ctypes bindings for Video4Linux2"
DESCRIPTION = "videodev2 provides Python ctypes bindings for the Linux Video4Linux2 API."
HOMEPAGE = "https://pypi.org/project/videodev2/"
LICENSE = "BSD-3-Clause"

LIC_FILES_CHKSUM = "file://README.md;beginline=43;endline=45;md5=9333e30eb7c2b1663297769a3a70bbf7"

PYPI_PACKAGE = "videodev2"

inherit pypi setuptools3

SRC_URI[sha256sum] = "c34ba70491d148c23a08cbacd8efabeb413cff5baa943a7548ac4abd1eb19e2a"
