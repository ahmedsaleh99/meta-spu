CMDLINE_SPLASH ?= " quiet splash"

CMDLINE += "${CMDLINE_SPLASH}"
