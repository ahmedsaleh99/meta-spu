PACKAGECONFIG:append:rpi = " pycamera"
